# Keil uVision project 1986ve1t.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: 1986ve1t +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./: main.c
software components: Device:Startup 1.5, Drivers:ADC 1.5, Drivers:ARINC429R 1.5, Drivers:ARINC429T 1.5, Drivers:BKP 1.5, Drivers:CAN 1.5, Drivers:DAC 1.5, Drivers:DMA 1.5, Drivers:EBC 1.5, Drivers:EEPROM 1.5, Drivers:Ethernet 1.5, Drivers:IWDG 1.5, Drivers:LIB 1.5, Drivers:MIL_STD_1553 1.5, Drivers:PORT 1.5, Drivers:POWER 1.5, Drivers:RST_CLK 1.5, Drivers:SSP 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5, Drivers:WWDG 1.5
